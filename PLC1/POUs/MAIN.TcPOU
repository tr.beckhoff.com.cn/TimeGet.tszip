PROGRAM MAIN
VAR
END_VAR

TimeGet();

END_PROGRAM
